# Keil uVision project STM32-DEMO.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-DEMO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c misc: --c99
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src;..\BSP\CONTROL;..\BSP\IIC;..\BSP\IMU;..\BSP\LED;..\BSP\MOTOR;..\BSP\MPU6050;..\BSP\PWM_IN;..\BSP\TIM;..\BSP\UART;..\BSP\Delay;..\BSP\HMC5883;..\BSP\ADC;..\BSP\KEY;..\BSP\OLED;..\BSP\APP;..\BSP\PARAM;..\BSP\NRF24L01;..\BSP\SPI;..\BSP\MS5611;..\BSP\EEPROM;..\BSP\Data;..\UserSys;..\PIDUSART;..\BSP\Ultrasonic;..\sys;..\BSP\STMFLASH;..\MALLOC;..\MAVLINK;..\UserSys\SONAR_CTR;..\UserSys\CHANNEL;..\UserSys\MODE;..\BSP\MPU6050\eMPL;..\BSP\MPU6050;..\UserSys\TRACK;..\UserSys\POS_CTR;..\BSP\OLED_MENU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_hd.s
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group SYS
    ./: main.c stm32f10x_it.c
  group BSP
    ../BSP/LED/: led.c
    ../BSP/OLED/: oled.c
    ../BSP/MOTOR/: moto.c
    ../BSP/TIM/: time.c
    ../BSP/UART/: usart.c
    ../BSP/Delay/: delay.c
    ../BSP/Data/: data.c
    ../BSP/KEY/: key.c
  group APP
    ../BSP/IMU/: IMU.c
    ../BSP/APP/: app.c
    ../BSP/PARAM/: Param.c
    ../BSP/CONTROL/: CONTROL.c
    ../BSP/OLED_MENU/: menu.c
  group UserSys
    ../UserSys/: UserSys.c
    ../UserSys/SONAR_CTR/: sonar_ctr.c
    ../UserSys/MODE/: mode.c status.c
    ../UserSys/TRACK/: track_line.c
    ../UserSys/POS_CTR/: pos_ctr.c
  group DMP
    ../BSP/MPU6050/: mpu6050.c
    ../BSP/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../BSP/IIC/: myiic.c
